require recipes-bsp/u-boot/u-boot-mender.inc
require u-boot-edm-mender.inc
